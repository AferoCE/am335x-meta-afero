#IMAGE_INSTALL += "am335x-binaries af-ipc af-util attrd af-conn"
IMAGE_INSTALL += "af-ipc af-util attrd af-conn"
